# Keil uVision project S520-B.uvprojx, settings and files
target S520-B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: S520-B
  AfterMake: fromelf --m32combined --output=$L@L.s19 !L
  AfterMake: fromelf --bin !L --output MAJOR.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1
  c include: ..\MDK_Core;..\MDK_STM32F10x_FWLib\inc;..\MDK_System\dwt_delay;..\MDK_System\sys;..\MDK_User;..\MDK_System\systick_delay;..\MDK_System\rx_data_queque;..\MDK_System\systick_delay;..\MDK_System\usart;..\MDK_System\iic;..\MDK_System\oldDemo;..\MDK_System\iap;..\MDK_System\iwdg;..\MDK_System\bsp_flash;..\MDK_Hardware\Inc;..\MDK_APP\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../MDK_Core/: startup_stm32f10x_cl.s
  group MDK_Core
    ../MDK_Core/: core_cm3.c
  group MDK_FWlib
    ../MDK_STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MDK_User
    ../MDK_User/: main.c stm32f10x_it.c system_stm32f10x.c
  group MDK_Hardware
    ../MDK_Hardware/Scr/: Bluetooth.c bsp_beep.c bsp_Fan.c bsp_hard.c bsp_Key.c bsp_led.c Compressor.c Pressure_PID.c TK1300F.c
  group MDK_System
    ../MDK_System/dwt_delay/: core_delay.c
    ../MDK_System/sys/: sys.c sys_status.c
    ../MDK_System/systick_delay/: systick_delay.c
    ../MDK_System/usart/: usart.c fire_usart.c
    ../MDK_System/iic/: softiic.c
    ../MDK_System/oldDemo/: oldTest.c
    ../MDK_System/iap/: iap_upgrade.c
    ../MDK_System/iwdg/: iwdg.c
    ../MDK_System/bsp_flash/: bsp_flash.c
  group MDK_APP
    ../MDK_APP/Scr/: GeneralTIM.c MyTypedef.c TimingSet.c Usart2_Decode.c Usart4_Decode.c
  group MDK_Doc
    ../MDK_Doc/: Doc.txt
